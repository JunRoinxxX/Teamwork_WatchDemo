# Keil uVision project KEY.uvprojx, settings and files
target Watch (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: KEY +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F411xE,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\GPIO;..\HARDWARE\ST7789;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\MPU_MAP;..\HARDWARE\ADS1118;..\HARDWARE\RTC;..\HARDWARE\Timer;..\HARDWARE\5_KEYS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/GPIO/: GPIO.c
    ../HARDWARE/ST7789/: fonts.c spi.c st7789.c
    ../HARDWARE/MPU6050/: myiic.c mpu6050.c
    ../HARDWARE/MPU6050/MPU_MAP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/ADS1118/: ads1118.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/Timer/: Timer.c
    ../HARDWARE/5_KEYS/: 5_keys.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f411xe.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_spi.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_exti.c
  group README
    ../: README.md
